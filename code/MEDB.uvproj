# Keil uVision project MEDB.uvproj, settings and files
target XinYu_MEDB (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: MEDB
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CMSIS;.\driver\inc;.\driver\src;.\user;.\delay;.\display;.\algorithm;.\DS18B20;.\Max30102;.\MLX90614;.\soft_i2c;.\uart;.\ADC;.\USB\inc;.\STM32_USB-FS-Device_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: main.c stm32f10x_it.c SysFunction.c usbio.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group driver
    ./driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group startup
    ./startup/: startup_stm32f10x_md.s
  group display
    ./display/: oled.c
  group delay
    ./delay/: delay.c
  group algorithm
    ./algorithm/: algorithm.c
  group DS18B20
    ./DS18B20/: DS18B20.c
  group Max30102
    ./Max30102/: Max_30100_I2C.c Max30100.c
  group MLX90614
    ./MLX90614/: MLX90614.c
  group soft_i2c
    ./soft_i2c/: soft_i2c_core.c
  group uart
    ./uart/: uart.c
  group ADC
    ./ADC/: Adc.c
  group USB
    ./USB/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group USB-FS-Device_Driver
    ./STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
